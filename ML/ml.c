#include <mll.h>
u8 random_for_s8()
{
  return rand()%(255)-127;
}

u8 random_for_float()
{
  return 2/(1+pow(1.05, rand()%100)) - 1;
}

float Logistic(float x)
{
        return 1/(1+pow(2, -x));
}
void init_weights()
{
    int i, j;
	
    for(i = 0; i < pixel_num; i++)
		for(j = 0; j < layer0_node; j++)
			weights0[i][j] = random_for_s8();
	
    for(i = 0; i < layer0_node; i++)
		for(j = 0; j < layer1_node; j++)
			weights1[i][j] = random_for_float();

		for(i = 0; i < layer1_node; i++)
		for(j = 0; j < output_node; j++)
			weights2[i][j] = random_for_float();
    //printf("³õÊ¼»¯È¨Öµ done\n");
}

u8 mlforward()
{
        int i, j;

				for(j = 0; j < layer0_node; j++)
        {
								for(i = 0; i < pixel_num; i++)
                   layer0[j] += pixel[i]*((s32)weights0[i][j]);
                layer0[j] += layer0_shift[j];
								layer0[j] = Logistic(layer0[j]);
        }

				for(j = 0; j < layer1_node; j++)
        {
								for(i = 0; i < layer0_node; i++)
                   layer1[j] += layer0[i]*weights1[i][j];
                layer1[j] += layer1_shift[j];
								layer1[j] = Logistic(layer1[j]);
        }
				
				for(j = 0; j < output_node; j++)
        {
								for(i = 0; i < layer1_node; i++)
                   output[j] += layer1[i]*weights2[i][j];
                output[j] += output_shift[j];
								output[j] = Logistic(output[j]);
        }

        if(output[0]>=output[1])
					return 0;
				else
					return 1;

}

void mlback(int x)
{
 				int i, j;
	
				s8 weights0_shift[pixel_num][layer0_node];
				float weights1_shift[layer0_node][layer1_node];
				float weights2_shift[layer1_node][output_node];
	
				float layer1_e[layer1_node];
				float layer0_e[layer0_node];
	
        //printf("ÑµÁ·Ä¿±ê = %d\n", x);
        for(i = 0; i < output_node; i++)
        {
                if(i == x){
                        for(j = 0; j < layer1_node; j++)
                                {weights2_shift[j][i] = (1-output[i])*layer1[j];
																layer1_e[j] += (1-output[i])*weights2[j][i];
																}
																output_shift[i] += (1-output[i])*(1-output[i])*output[i];
                }
                else
                {
                        for(j = 0; j < 8; j++)
                                {weights2_shift[j][i] = (-output[i])*layer1[j];
																layer1_e[j] += (-output[i])*weights2[j][i];
																}
																output_shift[i] += (-output[i])*(1-output[i])*output[i];
                }
        }


        for(i = 0; i < layer1_node; i++)
				{
                for(j = 0; j < layer0_node; j++)
                        {weights1_shift[j][i] = layer1_e[i]*layer0[j];
												layer0_e[j] += layer1_e[i]*weights1[j][i];
												}
								layer1_shift[i] += layer1_e[i]*layer1[i]*(1-layer1[i]);
				}
				
				for(i = 0; i < layer0_node; i++)
				{
                for(j = 0; j < pixel_num; j++)
                        {weights0_shift[j][i] = (s8)(layer0_e[i]*pixel[j]);
												}
								layer0_shift[i] = layer0_e[i]*layer0[i]*(1-layer0[i]);
				}

				for(i = 0; i < pixel_num; i++)
                for(j = 0; j < layer0_node; j++)
                        weights0[i][j] += weights0_shift[i][j];

				for(i = 0; i < layer0_node; i++)
                for(j = 0; j < layer1_node; j++)
                        weights1[i][j] += weights1_shift[i][j];
				
				for(i = 0; i < layer1_node; i++)
                for(j = 0; j < output_node; j++)
                        weights2[i][j] += weights2_shift[i][j];

}